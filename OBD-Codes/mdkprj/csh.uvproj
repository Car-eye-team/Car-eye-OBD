# Keil uVision project csh.uvproj, settings and files
target project (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: csh +hex
  AfterMake: fromelf --bin -o "./bin/ OR9WH-L3-A--OBD-1.0.1.bin" "./Obj/csh.axf"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: UP_LITTLE_ENDIAN,USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\;..\software\Libraries\STM32F10x_StdPeriph_Driver\inc;..\software\Libraries\CMSIS\CM3\CoreSupport;..\software\libset;..\software\source\app;..\software\source\ProtocolModule;..\software\source\source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group lib
    ../software/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_can.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_iwdg.c stm32f10x_adc.c stm32f10x_dma.c
  group CMSIS
    ../software/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group RVMDK
    ../software/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group libset
    ../software/libset/: stm32f10x_it.c system_stm32f10x.c
  group source
    ../software/source/source/: bsp.c main.c pidarith.c OilArith.c protocol.c
    ../../DS-06-3 - printandiwdog -NewClock - 副本/mdkprj/Obj/: OBD.lib
  group app
    ../software/source/app/: tools.c
